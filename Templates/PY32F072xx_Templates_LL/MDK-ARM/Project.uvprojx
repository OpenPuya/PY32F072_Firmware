# Keil uVision project Project.uvprojx, settings and files
target PY32F072xB_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.1.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F072xB,USE_FULL_LL_DRIVER
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F072_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F072\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f072.c
    ./: startup_py32f072xx.s
  group Application/User
    ../Src/: main.c py32f072_it.c
  group Drivers/PY32F072_HAL_Driver
    ../../../Drivers/PY32F072_HAL_Driver/Src/: py32f072_ll_utils.c
  group Doc
    ../: readme.txt
target PY32F072x9_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072x9 Puya
  pack: Puya.PY32F0xx_DFP.1.1.8
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00018000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F072x9,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x3000
target PY32F072x8_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F072x8,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target PY32F072x6_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072x6 Puya
  pack: Puya.PY32F0xx_DFP.1.1.8
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F072x6,USE_FULL_LL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
