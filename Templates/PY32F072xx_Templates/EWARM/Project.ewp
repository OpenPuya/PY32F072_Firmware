# IAR project Project.ewp, settings and files
configuration PY32F072xB_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F072xB Puya PY32F072xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072xB
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F072\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F072_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f072xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F072x9_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F072x9 Puya PY32F072x9
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072x9
  ILINK.IlinkIcfFile: py32f072x9_flash.icf
configuration PY32F072x8_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F072x8 Puya PY32F072x8
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072x8
  ILINK.IlinkIcfFile: py32f072x8_flash.icf
configuration PY32F072x6_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F072x6 Puya PY32F072x6
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072x6
  ILINK.IlinkIcfFile: py32f072x6_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f072.c
  group Drivers/PY32F072_HAL_Driver
    ../../../Drivers/PY32F072_HAL_Driver/Src/: py32f072_hal.c py32f072_hal_cortex.c py32f072_hal_dma.c py32f072_hal_gpio.c py32f072_hal_pwr.c py32f072_hal_rcc.c py32f072_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_py32f072xx.s
  group Example/User
    ../Src/: main.c py32f072_hal_msp.c py32f072_it.c
