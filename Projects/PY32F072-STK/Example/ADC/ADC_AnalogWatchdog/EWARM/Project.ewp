# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F072xB Puya PY32F072xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072xB
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F072xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F072\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F072_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f072xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F072xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F072xx_Start_Kit/: py32f072xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f072.c
  group Drivers/PY32F072_HAL_Driver
    ../../../../../../Drivers/PY32F072_HAL_Driver/Src/: py32f072_hal.c py32f072_hal_opa_ex.c py32f072_hal_opa.c py32f072_hal_tim.c py32f072_hal_tim_ex.c py32f072_hal_adc.c py32f072_hal_adc_ex.c
    ../../../../../../drivers/PY32F072_HAL_Driver/src/: py32f072_hal_rcc.c py32f072_hal_rcc_ex.c py32f072_hal_gpio.c py32f072_hal_dma.c py32f072_hal_pwr.c py32f072_hal_uart.c py32f072_hal_cortex.c
  group Example/EWARM
    ./: startup_py32f072xx.s
  group Example/User
    ../Src/: main.c py32f072_hal_msp.c py32f072_it.c
