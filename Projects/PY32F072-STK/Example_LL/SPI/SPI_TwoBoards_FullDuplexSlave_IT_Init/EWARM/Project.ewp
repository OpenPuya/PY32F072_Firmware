# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F072xB Puya PY32F072xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: PY32F072xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F072xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F072\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F072_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f072xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/PY32F072xx_Start_Kit/: py32f072xx_ll_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f072.c
  group Drivers/PY32F072_HAL_Driver
    ../../../../../../Drivers/PY32F072_HAL_Driver/Src/: py32f072_ll_utils.c py32f072_ll_spi.c py32f072_ll_gpio.c py32f072_ll_rcc.c py32f072_ll_dma.c
  group Example/EWARM
    ./: startup_py32f072xx.s
  group Example/User
    ../Src/: main.c py32f072_it.c
