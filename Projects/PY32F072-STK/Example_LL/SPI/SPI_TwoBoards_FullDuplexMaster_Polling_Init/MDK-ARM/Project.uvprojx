# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F072xB,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32F072_HAL_Driver\Inc;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F072\Include;..\..\..\..\..\..\Drivers\BSP\PY32F072xx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f072.c
    ./: startup_py32f072xx.s
  group Application/User
    ../Src/: main.c py32f072_it.c
  group BSP/py32f072xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F072xx_Start_Kit/: py32f072xx_ll_Start_Kit.c
  group Drivers/PY32F072_HAL_Driver
    ../../../../../../Drivers/PY32F072_HAL_Driver/Src/: py32f072_ll_utils.c py32f072_ll_spi.c py32f072_ll_gpio.c py32f072_ll_rcc.c py32f072_ll_dma.c
  group Doc
    ../: readme.txt
